Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-13T12:12:41+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRS_57_DUA_UN_round firedamper fdc40_sacs:FDC40 MF2 RS O, NLRS_57_DUA_UN_round firedamper fdc40_sacs:FDC40 MF2 RS O:1104779
In: Default
Type - Description: Ronde brandklep; Classification: 57.70 (Uniformat); Material: NLRS_A_SACS_SVZ (2)
Type - Constraints - Default Elevation: 0 mm
Type - General - Article_Data: FDC40_Article_Data; Selection_Factors: Selection_Factors
Type - Identity Data - Assembly Code: 57.70; Description: Ronde brandklep; Manufacturer: Solid Air Climate Solutions; Model: Brandklep - Rond; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 13-05-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.01; NLRS_C_description: Ronde brandklep; NLRS_C_niveau ontwikkeling: LOD400; Type Name: FDC40 MF2 RS O; URL: https://solid-air.nl/producten/solid-air-ronde-brandklep-fdc40/
Type - Materials and Finishes - Blade material: Hittebestendig dikte 25mm; Casing material: Gegalvaniseerd plaatstaal; Fuse temperatuur (default): 72 °C
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_round firedamper fdc40_sacs
Type - Visibility - Show Symbol: yes
Type - Pset_ConcreteElementGeneral - FireRating: EN 1366-2 and EN 13501-3, 2h
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: FDC40 MF2 RS O; sets with these values: 2
Pset_ProvisionForVoid - Depth: 296 mm
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.00602958 m2; NLRS_C_lengte: 296 mm; NLRS_M_c01_diameter: 450 mm; SACS_Duct_Used_Size: 450 mm; Volume: 0.00000197509 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 12364; NLRS_C_model: FDC40 MF2 RS O 450; SACS_Article_Code: 9250012855; SACS_Gross_Cost: 563; SACS_Price_Date: 3-12-2021
Insulation - Insulation Thickness: 0 mm
Lining - Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Air_Velocity: 0 m/s; SACS_Lp_dBA: 3; SACS_Manual_Airflow: 0 m3/s; SACS_Nominal_Max_Flow: 1908.61 m3/s; SACS_Nominal_Min_Flow: 238.611 m3/s; SACS_Use_Manual_Airflow: no
Model Properties - SACS_Belimo_Rotation (1-3): 1; SACS_Option_1: MF2 = installatieframe 2; SACS_Option_2: RS = Handbediend, met eindschakelaars; SACS_Option_3: O = Geen Accessoire
Other - Family: NLRS_57_DUA_UN_round firedamper fdc40_sacs; Family and Type: NLRS_57_DUA_UN_round firedamper fdc40_sacs: FDC40 MF2 RS O; Type: FDC40 MF2 RS O; Type Id: 1104701
Phasing - Phase Created: New Construction
Visibility - SACS_Disable_Warning: no

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
